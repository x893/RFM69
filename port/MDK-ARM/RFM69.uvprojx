# Keil uVision project RFM69.uvprojx, settings and files
target RFM69-Node (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(48000000) ELITTLE
  output: RFM69-Node
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\efm32;..\;..\..\;..\efm32\usb\inc;..\efm32\emlib\inc;..\efm32\kits\common\bsp;..\efm32\kits\EFM32GG_STK3700\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group lib
    ../../: RFM69.cpp
  group examples
    ../Examples/Node/: Node.cpp
    ../Examples/Gateway/: Gateway.cpp
  group port
    ../: main.cpp Print.cpp WString.cpp stdlib-arm.c SPIFlash.cpp
    ../efm32/: WInterrupts.c
  group port/efm32
    ../efm32/: startup_efm32gg.s system_efm32gg.c wiring.c HardwareSerial.cpp SPI.cpp
    ../efm32/emlib/src/: em_cmu.c em_emu.c em_system.c em_gpio.c em_usart.c em_int.c em_timer.c
  group bsp/STK3700
    ../efm32/kits/common/bsp/: bsp_stk_leds.c
  group usb/efm32
    ../efm32/: cdc.c usbio.c
    ../efm32/usb/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbdint.c em_usbhal.c em_usbtimer.c
target RFM69-Gateway (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: as above
  output: RFM69-Node
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
